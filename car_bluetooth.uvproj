# Keil uVision project car_bluetooth.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W204S Series STC
  cpu: IRAM(0-0xFF) IROM(0-0x0FF8) CLOCK(35000000) MODP2
  output: car_bluetooth +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: car.c follow.c motor.c avoid.c avoid.h follow.h
