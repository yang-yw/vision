ORG	0000H
AJMP START	
ORG	0030H
START:	
	MOV	DPTR,#7FFFH
LOOP:	
	MOV	A,#0FFH
	MOVX	@DPTR,A
	ACALL	DELAY
	MOV	A,#00H
	MOVX	@DPTR,A
	ACALL	DELAY
	AJMP	LOOP 
	
DELAY:	
    MOV	R7,#0FFH
D1:	
	MOV	R6,#0FFH
D2:	
	MOV R5,#00FH
D3:	
	DJNZ    R5,D3
	DJNZ	R6,D2
	DJNZ	R7,D1
	
	RET
END
